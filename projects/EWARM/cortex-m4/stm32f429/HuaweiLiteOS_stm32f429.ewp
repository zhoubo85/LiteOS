# IAR project HuaweiLiteOS_stm32f429.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\kernel\base\include; ..\..\..\..\kernel\base\core; ..\..\..\..\kernel\include; ..\..\..\..\platform\bsp\sample\config; ..\..\..\..\platform\cpu\arm\cortex-m4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HuaweiLiteOS_stm32f429.bin
  ILINK.IlinkOutputFile: HuaweiLiteOS_stm32f429.out
  ILINK.IlinkIcfFile: stm32f429xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/kernel/base
    ../../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../../../kernel/base/misc/: los_misc.c
    ../../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/platform/bsp
    ../../../../platform/bsp/sample/config/: los_config.c
  group Huawei_LiteOS/platform/cpu
    ../../../../platform/cpu/arm/cortex-m4/: los_dispatch.s los_hw.c los_hw_tick.c los_hwi.c los_vendor.s
